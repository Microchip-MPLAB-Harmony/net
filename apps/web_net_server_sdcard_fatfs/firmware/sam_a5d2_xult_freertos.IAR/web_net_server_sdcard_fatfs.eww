<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\web_net_server_sdcard_fatfs.ewp</path>
    </project>
</workspace>
