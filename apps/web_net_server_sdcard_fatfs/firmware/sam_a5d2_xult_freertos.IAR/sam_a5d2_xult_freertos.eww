<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\web_server_sdcard_fatfs_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
