# IAR project web_net_server_sdcard_fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: __SAM9X60__
  ICCARM.CCDiagSuppress: Pe188, Pe186, Pe1029
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\firmware\src\config\sam_9x60_ek\library; ..\..\firmware\src\config\sam_9x60_ek\library\tcpip\src; ..\..\firmware\src\config\sam_9x60_ek\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: web_net_server_sdcard_fatfs.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_9x60_ek\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../src/config/sam_9x60_ek/: sam_9x60_ek.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h http_net_print.h
    ../src/config/sam_9x60_ek/library/tcpip/: arp.h berkeley_api.h ddns.h dhcp.h dhcps.h dhcpv6.h dns.h dnss.h ftp.h ftpc.h http.h http_net.h icmp.h icmpv6.h igmp.h iperf.h ipv4.h ipv6.h lldp.h nbns.h ndp.h smtp.h smtpc.h snmp.h snmpv3.h sntp.h tcp.h tcpip.h tcpip_announce.h tcpip_commands.h tcpip_common_ports.h tcpip_ethernet.h tcpip_heap.h tcpip_helpers.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_reboot.h telnet.h tftpc.h tftps.h udp.h zero_conf_link_local.h zero_conf_multicast_dns.h
    ../src/config/sam_9x60_ek/library/tcpip/src/: arp_manager.h arp_private.h berkeley_manager.h ddns_manager.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcpv6_manager.h dhcpv6_private.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h hash_fnv.h http_manager.h http_net_manager.h http_net_private.h http_private.h icmp_manager.h icmpv6_manager.h igmp_manager.h igmp_private.h iperf_manager.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h link_list.h lldp_manager.h lldp_private.h lldp_tlv.h nbns_manager.h ndp_manager.h ndp_private.h oahash.h smtp_manager.h smtpc_manager.h smtpc_private.h snmp_manager.h snmp_private.h snmpv3_private.h sntp_manager.h tcp_manager.h tcp_private.h tcpip_announce_manager.h tcpip_commands_manager.h tcpip_heap_alloc.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_reboot_manager.h tcpip_types.h telnet_manager.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h udp_manager.h udp_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h
    ../src/config/sam_9x60_ek/bsp/: bsp.h
    ../src/config/sam_9x60_ek/: configuration.h definitions.h device_cache.h system_config.h system_definitions.h toolchain_specifics.h user.h
    ../src/config/sam_9x60_ek/peripheral/mmu/: cp15.h plib_mmu.h
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
    ../src/config/sam_9x60_ek/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_9x60_ek/driver/: driver.h driver_common.h
    ../src/config/sam_9x60_ek/driver/ethphy/: drv_ethphy.h
    ../src/config/sam_9x60_ek/driver/ethphy/src/: drv_ethphy_local.h
    ../src/config/sam_9x60_ek/driver/ethphy/src/dynamic/: drv_extphy_ksz8081.h drv_extphy_regs.h
    ../src/config/sam_9x60_ek/driver/miim/: drv_miim.h
    ../src/config/sam_9x60_ek/driver/miim/config/: drv_miim_config.h
    ../src/config/sam_9x60_ek/driver/miim/src/: drv_miim_local.h
    ../src/config/sam_9x60_ek/driver/sdmmc/: drv_sdmmc.h drv_sdmmc_definitions.h
    ../src/config/sam_9x60_ek/driver/sdmmc/src/: drv_sdmmc_local.h
    ../src/config/sam_9x60_ek/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_9x60_ek/library/tcpip/src/common/: helpers.h sys_fs_shell.h
    ../src/config/sam_9x60_ek/driver/emac/src/dynamic/: drv_emac_dcpt_lists.h drv_emac_lib.h
    ../src/config/sam_9x60_ek/driver/emac/: drv_emac.h
    ../src/config/sam_9x60_ek/driver/emac/src/: drv_emac_local.h
    ../src/config/sam_9x60_ek/system/fs/mpfs/: mpfs.h
    ../src/config/sam_9x60_ek/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_9x60_ek/net_pres/pres/: net_pres.h net_pres_certstore.h net_pres_enc_glue.h net_pres_encryptionproviderapi.h net_pres_socketapi.h net_pres_socketapiconversion.h net_pres_transportapi.h
    ../src/config/sam_9x60_ek/net_pres/pres/src/: net_pres_local.h
    ../src/config/sam_9x60_ek/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.h
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.h
    ../src/config/sam_9x60_ek/peripheral/dbgu/: plib_dbgu.h plib_dbgu_common.h
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.h
    ../src/config/sam_9x60_ek/peripheral/sdmmc/: plib_sdmmc0.h plib_sdmmc_common.h
    ../src/config/sam_9x60_ek/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
    ../src/config/sam_9x60_ek/system/: sys_clk_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h sys_time_h2_adapter.h system.h system_common.h system_media.h system_module.h
    ../src/config/sam_9x60_ek/system/command/: sys_command.h
    ../src/config/sam_9x60_ek/system/console/: sys_console.h
    ../src/config/sam_9x60_ek/system/debug/: sys_debug.h
    ../src/config/sam_9x60_ek/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_9x60_ek/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_9x60_ek/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_9x60_ek/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek/system/time/src/: sys_time_local.h
  group IAR Project Connection File/Source Files
    ../src/: app.c custom_http_net_app.c http_net_print.c main_sam_9x60.c
    ../src/config/sam_9x60_ek/library/tcpip/src/: arp.c dhcp.c dns.c hash_fnv.c helpers.c http_net.c icmp.c iperf.c ipv4.c oahash.c smtpc.c sntp.c tcp.c tcpip_announce.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c telnet.c tftpc.c tftps.c udp.c
    ../src/web_pages/: auth.htm cookies.htm dynvars.htm footer.htm forms.htm harmony.gif header.htm index.htm leds.cgi mchp.css mchp.gif mchp.js snmp.bib ssi.htm status.xml upload.htm
    ../src/config/sam_9x60_ek/bsp/: bsp.c
    ../src/web_pages/protect/: config.htm index.htm reboot.cgi reboot.htm
    ../src/config/sam_9x60_ek/: cstartup.s exceptions.c initialization.c interrupts.c tasks.c vectortrap.s
    ../src/config/sam_9x60_ek/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_9x60_ek/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
    ../src/config/sam_9x60_ek/driver/miim/src/dynamic/: drv_miim_eMac.c
    ../src/config/sam_9x60_ek/driver/sdmmc/src/: drv_sdmmc.c drv_sdmmc_file_system.c
    ../src/config/sam_9x60_ek/stdio/: iar_monitor.c
    ../src/web_pages/dyndns/: index.htm
    ../src/web_pages/email/: index.htm
    ../src/config/sam_9x60_ek/driver/emac/src/dynamic/: drv_emac.c mac_drvr_lib_SAM9X60.c drv_emac_statistics.c
    ../src/config/sam_9x60_ek/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_9x60_ek/net_pres/pres/src/: net_pres.c
    ../src/config/sam_9x60_ek/net_pres/pres/: net_pres_cert_store.c net_pres_enc_glue.c
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.c
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.c
    ../src/config/sam_9x60_ek/peripheral/dbgu/: plib_dbgu.c
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.c
    ../src/config/sam_9x60_ek/peripheral/sdmmc/: plib_sdmmc0.c
    ../src/config/sam_9x60_ek/peripheral/tc/: plib_tc0.c
    ../src/web_pages/snmp/: snmpconfig.htm
    ../src/config/sam_9x60_ek/system/command/src/: sys_command.c
    ../src/config/sam_9x60_ek/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
    ../src/config/sam_9x60_ek/system/debug/src/: sys_debug.c sys_debug_local.h
    ../src/config/sam_9x60_ek/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_9x60_ek/library/tcpip/src/common/: sys_fs_shell.c
    ../src/config/sam_9x60_ek/system/int/src/: sys_int.c
    ../src/config/sam_9x60_ek/system/time/src/: sys_time.c
    ../src/config/sam_9x60_ek/system/: sys_time_h2_adapter.c
