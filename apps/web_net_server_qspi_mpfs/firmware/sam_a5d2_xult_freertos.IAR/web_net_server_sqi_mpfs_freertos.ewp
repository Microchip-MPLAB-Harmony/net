# IAR project web_net_server_sqi_mpfs_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: __SAMA5D2__; __PIC32C__
  ICCARM.CCDiagSuppress: Pe186, Pe188
  ICCARM.CCIncludePath2: ..\..\firmware\src\config\sam_a5d2_xult_freertos\library; ..\..\firmware\src\config\sam_a5d2_xult_freertos\library\tcpip\src; ..\..\firmware\src\config\sam_a5d2_xult_freertos\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult_freertos; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\config\sam_a5d2_xult_freertos; ..\src\third_party\rtos\FreeRTOS\Source\Include; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\..\firmware\src\config\sam_a5d2_xult_freertos\library; ..\..\firmware\src\config\sam_a5d2_xult_freertos\library\tcpip\src; ..\..\firmware\src\config\sam_a5d2_xult_freertos\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: web_net_server_sqi_mpfs_freertos.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult_freertos\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  group (top)
    ../src/: rawWrite.c
    ../src/config/sam_a5d2_xult_freertos/: sam_a5d2_xult_freertos.ipcf
  group IAR Project Connection File/Header Files
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h http_net_print.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/: arp.h berkeley_api.h ddns.h dhcp.h dhcps.h dhcpv6.h dns.h dnss.h ftp.h http.h http_net.h icmp.h icmpv6.h igmp.h iperf.h ipv4.h ipv6.h lldp.h nbns.h ndp.h smtp.h smtpc.h snmp.h snmpv3.h sntp.h tcp.h tcpip.h tcpip_announce.h tcpip_commands.h tcpip_common_ports.h tcpip_ethernet.h tcpip_heap.h tcpip_helpers.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_reboot.h telnet.h tftpc.h tftps.h udp.h zero_conf_link_local.h zero_conf_multicast_dns.h
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/: arp_manager.h arp_private.h berkeley_manager.h ddns_manager.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcpv6_manager.h dhcpv6_private.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h hash_fnv.h http_manager.h http_net_manager.h http_net_private.h http_private.h icmp_manager.h icmpv6_manager.h igmp_manager.h igmp_private.h iperf_manager.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h link_list.h lldp_manager.h lldp_private.h lldp_tlv.h nbns_manager.h ndp_manager.h ndp_private.h oahash.h smtp_manager.h smtpc_manager.h smtpc_private.h snmp_manager.h snmp_private.h snmpv3_private.h sntp_manager.h tcp_manager.h tcp_private.h tcpip_announce_manager.h tcpip_commands_manager.h tcpip_heap_alloc.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_reboot_manager.h tcpip_types.h telnet_manager.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h udp_manager.h udp_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult_freertos/: configuration.h definitions.h device_cache.h FreeRTOSConfig.h system_config.h system_definitions.h toolchain_specifics.h user.h
    ../src/third_party/rtos/FreeRTOS/Source/Include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_a5d2_xult_freertos/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/: drv_ethphy.h
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/src/: drv_ethphy_local.h
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/src/dynamic/: drv_extphy_ksz8081.h drv_extphy_regs.h
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/: drv_gmac.h
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/src/: drv_gmac_local.h
    ../src/config/sam_a5d2_xult_freertos/driver/memory/: drv_memory.h drv_memory_definitions.h
    ../src/config/sam_a5d2_xult_freertos/driver/memory/src/: drv_memory_local.h
    ../src/config/sam_a5d2_xult_freertos/driver/miim/: drv_miim.h
    ../src/config/sam_a5d2_xult_freertos/driver/miim/config/: drv_miim_config.h
    ../src/config/sam_a5d2_xult_freertos/driver/miim/src/: drv_miim_local.h
    ../src/config/sam_a5d2_xult_freertos/driver/miim/src/dynamic/: drv_miim_mapping.h
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/: drv_mx25l.h drv_mx25l_definitions.h
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/src/: drv_mx25l_local.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/common/: helpers.h sys_fs_wrapper.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/: mpfs.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/: net_pres.h net_pres_certstore.h net_pres_enc_glue.h net_pres_encryptionproviderapi.h net_pres_socketapi.h net_pres_socketapiconversion.h net_pres_transportapi.h
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/src/: net_pres_local.h
    ../src/config/sam_a5d2_xult_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/qspi/: plib_qspi0.h plib_qspi_common.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/uart/: plib_uart1.h plib_uart_common.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: portASM.h portmacro.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult_freertos/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xult_freertos/system/: sys_clk_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h sys_time_h2_adapter.h system_media.h
    ../src/config/sam_a5d2_xult_freertos/system/command/: sys_command.h
    ../src/config/sam_a5d2_xult_freertos/system/console/: sys_console.h
    ../src/config/sam_a5d2_xult_freertos/system/debug/: sys_debug.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_a5d2_xult_freertos/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xult_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time_local.h
  group IAR Project Connection File/Source Files
    ../src/: app.c custom_http_net_app.c http_net_print.c main.c mpfs_net_img.c
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/: arp.c dhcp.c dns.c hash_fnv.c helpers.c http_net.c icmp.c iperf.c ipv4.c nbns.c oahash.c smtpc.c sntp.c tcp.c tcpip_announce.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c telnet.c tftpc.c udp.c
    ../src/web_pages/: auth.htm cookies.htm dynvars.htm footer.htm forms.htm harmony.gif header.htm index.htm leds.cgi mchp.css mchp.gif mchp.js snmp.bib ssi.htm status.xml upload.htm
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.c
    ../src/web_pages/protect/: config.htm index.htm reboot.cgi reboot.htm
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
    ../src/config/sam_a5d2_xult_freertos/: cstartup.s exceptions.c fault_handlers.c freertos_hooks.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xult_freertos/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_a5d2_xult_freertos/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
    ../src/config/sam_a5d2_xult_freertos/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samA5D2.c
    ../src/config/sam_a5d2_xult_freertos/driver/memory/src/: drv_memory.c drv_memory_file_system.c
    ../src/config/sam_a5d2_xult_freertos/driver/miim/src/dynamic/: drv_miim.c
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/src/: drv_mx25l.c
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: FreeRTOS_tick_config.c port.c portASM.s
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_a5d2_xult_freertos/stdio/: iar_monitor.c
    ../src/web_pages/dyndns/: index.htm
    ../src/web_pages/email/: index.htm
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/src/: net_pres.c
    ../src/config/sam_a5d2_xult_freertos/net_pres/pres/: net_pres_cert_store.c net_pres_enc_glue.c
    ../src/config/sam_a5d2_xult_freertos/osal/: osal_freertos.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/qspi/: plib_qspi0.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/uart/: plib_uart1.c
    ../src/web_pages/snmp/: snmpconfig.htm
    ../src/config/sam_a5d2_xult_freertos/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xult_freertos/system/command/src/: sys_command.c
    ../src/config/sam_a5d2_xult_freertos/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
    ../src/config/sam_a5d2_xult_freertos/system/debug/src/: sys_debug.c sys_debug_local.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_a5d2_xult_freertos/library/tcpip/src/common/: sys_fs_wrapper.c
    ../src/config/sam_a5d2_xult_freertos/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time.c
    ../src/config/sam_a5d2_xult_freertos/system/: sys_time_h2_adapter.c
