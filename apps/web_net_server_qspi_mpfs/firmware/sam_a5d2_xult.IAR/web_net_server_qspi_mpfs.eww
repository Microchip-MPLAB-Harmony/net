<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\web_net_server_qspi_mpfs.ewp</path>
    </project>
</workspace>
