<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\wolfssl_tcp_server.ewp</path>
    </project>
</workspace>
