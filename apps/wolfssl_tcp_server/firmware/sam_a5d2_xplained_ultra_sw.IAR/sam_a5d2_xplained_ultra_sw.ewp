# IAR project sam_a5d2_xplained_ultra_sw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: __PIC32C__; __FPU_PRESENT=1; HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN
  ICCARM.CCDiagSuppress: Pe186, Pe188, Pa089
  ICCARM.CCIncludePath2: ..\..\firmware\src\third_party\wolfcrypt_support; ..\..\firmware\src\third_party\wolfssl; ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw\library; ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw\library\tcpip\src; ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\wolfssl\wolfssl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xplained_ultra_sw.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __FPU_PRESENT=1; HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xplained_ultra_sw/: sam_a5d2_xplained_ultra_sw.ipcf
  group IAR Project Connection File/Header Files
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h cpuid.h cryptocb.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h selftest.h settings.h sha.h sha256.h sha3.h sha512.h signature.h sp.h sp_int.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_pkcs11.h wc_port.h wolfevent.h wolfmath.h
    ../src/: app.h
    ../src/config/sam_a5d2_xplained_ultra_sw/library/tcpip/: arp.h berkeley_api.h ddns.h dhcp.h dhcps.h dhcpv6.h dns.h dnss.h ftp.h ftpc.h http.h http_net.h icmp.h icmpv6.h igmp.h iperf.h ipv4.h ipv6.h lldp.h nbns.h ndp.h smtp.h smtpc.h snmp.h snmpv3.h sntp.h tcp.h tcpip.h tcpip_announce.h tcpip_commands.h tcpip_common_ports.h tcpip_ethernet.h tcpip_heap.h tcpip_helpers.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_reboot.h telnet.h tftpc.h tftps.h udp.h zero_conf_link_local.h zero_conf_multicast_dns.h
    ../src/config/sam_a5d2_xplained_ultra_sw/library/tcpip/src/: arp_manager.h arp_private.h berkeley_manager.h ddns_manager.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcpv6_manager.h dhcpv6_private.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h hash_fnv.h http_manager.h http_net_manager.h http_net_private.h http_private.h icmp_manager.h icmpv6_manager.h igmp_manager.h igmp_private.h iperf_manager.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h link_list.h lldp_manager.h lldp_private.h lldp_tlv.h nbns_manager.h ndp_manager.h ndp_private.h oahash.h smtp_manager.h smtpc_manager.h smtpc_private.h snmp_manager.h snmp_private.h snmpv3_private.h sntp_manager.h tcp_manager.h tcp_private.h tcpip_announce_manager.h tcpip_commands_manager.h tcpip_heap_alloc.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_reboot_manager.h tcpip_types.h telnet_manager.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h udp_manager.h udp_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xplained_ultra_sw/bsp/: bsp.h
    ../src/third_party/wolfssl/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h sniffer.h sniffer_error.h ssl.h test.h version.h wolfio.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xplained_ultra_sw/: config.h configuration.h definitions.h device_cache.h system_config.h system_definitions.h toolchain_specifics.h user.h
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/port/pic32/: crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_crya_saml11.h crypt_ecc_ba414e.h crypt_ecc_pukcl.h crypt_pukcl_definitions.h crypt_pukcl_functions.h crypt_rng_hw.h crypt_rsa_pukcl.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h crypt_wolfcryptcb.h CryptoLib_cf_pb.h CryptoLib_ClearFlags_pb.h CryptoLib_Comp_pb.h CryptoLib_CondCopy_pb.h CryptoLib_CRT_pb.h CryptoLib_Div_pb.h CryptoLib_ExpMod_pb.h CryptoLib_FastCopy_pb.h CryptoLib_Fill_pb.h CryptoLib_Fmult_pb.h CryptoLib_GCD_pb.h CryptoLib_GF2NEccAdd_pb.h CryptoLib_GF2NEccConv_pb.h CryptoLib_GF2NEccDbl_pb.h CryptoLib_GF2NEccMul_pb.h CryptoLib_GF2NEcDsa_pb.h CryptoLib_Hardware_pb.h CryptoLib_Headers_pb.h CryptoLib_JumpTable_pb.h CryptoLib_mapping_pb.h CryptoLib_PrimeGen_pb.h CryptoLib_Rc_pb.h CryptoLib_RedMod_pb.h CryptoLib_Rng_pb.h CryptoLib_SelfTest_pb.h CryptoLib_Services_pb.h CryptoLib_Smult_pb.h CryptoLib_Square_pb.h CryptoLib_Swap_pb.h CryptoLib_typedef_pb.h CryptoLib_ZpEccAdd_pb.h CryptoLib_ZpEccAddSub_pb.h CryptoLib_ZpEccConv_pb.h CryptoLib_ZpEccDbl_pb.h CryptoLib_ZpEccMul_pb.h CryptoLib_ZpEccQuickDualMul_pb.h CryptoLib_ZpEcDsa_pb.h pic32mz-crypt.h
    ../src/config/sam_a5d2_xplained_ultra_sw/crypto/: crypto.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/ethphy/: drv_ethphy.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/ethphy/src/: drv_ethphy_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/ethphy/src/dynamic/: drv_extphy_ksz8081.h drv_extphy_regs.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/gmac/: drv_gmac.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/gmac/src/: drv_gmac_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/miim/: drv_miim.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/miim/src/: drv_miim_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/miim/src/dynamic/: drv_miim_mapping.h
    ../src/config/sam_a5d2_xplained_ultra_sw/library/tcpip/src/common/: helpers.h sys_fs_shell.h
    ../src/config/sam_a5d2_xplained_ultra_sw/net_pres/pres/: net_pres.h net_pres_certstore.h net_pres_enc_glue.h net_pres_encryptionproviderapi.h net_pres_socketapi.h net_pres_socketapiconversion.h net_pres_transportapi.h
    ../src/config/sam_a5d2_xplained_ultra_sw/net_pres/pres/src/: net_pres_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/l2cc/: plib_l2cc.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/uart/: plib_uart1.h plib_uart_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/: sys_clk_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h sys_time_h2_adapter.h system.h system_common.h system_module.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/command/: sys_command.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/console/: sys_console.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/debug/: sys_debug.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/src/: sys_time_local.h
  group IAR Project Connection File/Source Files
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c cryptocb.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_int.c sp_x86_64.c srp.c tfm.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xplained_ultra_sw/library/tcpip/src/: arp.c dhcp.c dns.c hash_fnv.c helpers.c icmp.c ipv4.c nbns.c oahash.c sntp.c tcp.c tcpip_announce.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c udp.c
    ../src/config/sam_a5d2_xplained_ultra_sw/bsp/: bsp.c
    ../src/third_party/wolfssl/src/: crl.c internal.c keys.c ocsp.c sniffer.c ssl.c tls.c tls13.c wolfio.c
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/port/pic32/: crypt_aes_sam6149.c crypt_aes_u2238.c crypt_ecc_ba414e.c crypt_ecc_pukcl.c crypt_pukcl_functions.c crypt_rng_sam6334.c crypt_rng_u2242.c crypt_rsa_pukcl.c crypt_sam_u2803.c crypt_sha1_sam11105.c crypt_sha1_sam6156.c crypt_sha224_sam11105.c crypt_sha224_sam6156.c crypt_sha256_sam11105.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_tdes_sam6150.c crypt_wolfcryptcb.c pic32mz-crypt.c
    ../src/config/sam_a5d2_xplained_ultra_sw/crypto/src/: crypto.c
    ../src/config/sam_a5d2_xplained_ultra_sw/: cstartup.s fault_handlers.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samA5D2.c
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/miim/src/dynamic/: drv_miim.c
    ../src/config/sam_a5d2_xplained_ultra_sw/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xplained_ultra_sw/net_pres/pres/src/: net_pres.c
    ../src/config/sam_a5d2_xplained_ultra_sw/net_pres/pres/: net_pres_cert_store.c net_pres_enc_glue.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/l2cc/: plib_l2cc.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/uart/: plib_uart1.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/command/src/: sys_command.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/debug/src/: sys_debug.c sys_debug_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/src/: sys_time.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/: sys_time_h2_adapter.c
