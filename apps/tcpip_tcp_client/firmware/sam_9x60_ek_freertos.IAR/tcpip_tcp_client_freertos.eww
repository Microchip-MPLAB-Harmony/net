<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\tcpip_tcp_client_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
