# IAR project tcpip_tcp_client.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __PIC32C__
  ICCARM.CCIncludePath2: ..\src\config\sam_e54_xpro_iar\library; ..\src\config\sam_e54_xpro_iar\library\tcpip\src; ..\src\config\sam_e54_xpro_iar\library\tcpip\src\common; ..\src; ..\src\config\sam_e54_xpro_iar; ..\src\packs\ATSAME54P20A_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tcpip_tcp_client.hex
  ILINK.IlinkOutputFile: sam_e54_xpro_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_e54_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
    ../src/config/sam_e54_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: configuration.h definitions.h device_cache.h system_config.h system_definitions.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver
    ../src/config/sam_e54_xpro_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/ethphy
    ../src/config/sam_e54_xpro_iar/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/ethphy/src
    ../src/config/sam_e54_xpro_iar/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic/: drv_extphy_ksz8091.h drv_extphy_regs.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/gmac
    ../src/config/sam_e54_xpro_iar/driver/gmac/: drv_gmac.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/gmac/src
    ../src/config/sam_e54_xpro_iar/driver/gmac/src/: drv_gmac_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/gmac/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/miim
    ../src/config/sam_e54_xpro_iar/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/miim/src
    ../src/config/sam_e54_xpro_iar/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/miim/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/library/tcpip
    ../src/config/sam_e54_xpro_iar/library/tcpip/: arp.h berkeley_api.h ddns.h dhcp.h dhcps.h dhcpv6.h dns.h dnss.h ftp.h ftpc.h http.h http_net.h icmp.h icmpv6.h igmp.h iperf.h ipv4.h ipv6.h lldp.h nbns.h ndp.h smtp.h smtpc.h snmp.h snmpv3.h sntp.h tcp.h tcpip.h tcpip_announce.h tcpip_commands.h tcpip_common_ports.h tcpip_ethernet.h tcpip_heap.h tcpip_helpers.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_reboot.h telnet.h tftpc.h tftps.h udp.h zero_conf_link_local.h zero_conf_multicast_dns.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/library/tcpip/src
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/: arp_manager.h arp_private.h berkeley_manager.h ddns_manager.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcpv6_manager.h dhcpv6_private.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h hash_fnv.h http_manager.h http_net_manager.h http_net_private.h http_private.h icmp_manager.h icmpv6_manager.h igmp_manager.h igmp_private.h iperf_manager.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h link_list.h lldp_manager.h lldp_private.h lldp_tlv.h nbns_manager.h ndp_manager.h ndp_private.h oahash.h smtp_manager.h smtpc_manager.h smtpc_private.h snmp_manager.h snmp_private.h snmpv3_private.h sntp_manager.h tcp_manager.h tcp_private.h tcpip_announce_manager.h tcpip_commands_manager.h tcpip_heap_alloc.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_reboot_manager.h tcpip_types.h telnet_manager.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h udp_manager.h udp_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/library/tcpip/src/common
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/net_pres/pres
    ../src/config/sam_e54_xpro_iar/net_pres/pres/: net_pres.h net_pres_socketapi.h net_pres_socketapiconversion.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/evsys
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/sercom/usart
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/usart/: plib_sercom2_usart.h plib_sercom_usart_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/tc
    ../src/config/sam_e54_xpro_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system
    ../src/config/sam_e54_xpro_iar/system/: sys_clk_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h sys_time_h2_adapter.h system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/cache
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/command
    ../src/config/sam_e54_xpro_iar/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/console
    ../src/config/sam_e54_xpro_iar/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/debug
    ../src/config/sam_e54_xpro_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/int
    ../src/config/sam_e54_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/time
    ../src/config/sam_e54_xpro_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e54_xpro_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP
    ../src/packs/ATSAME54P20A_DFP/: atsame54p20a.h atsame54p20a_compat.h device.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/component
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/pio
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Harmony3/Linker File
    ../src/config/sam_e54_xpro_iar/: flash.icf
  group Harmony3/Source Files
    ../src/: app.c app_commands.c main.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8091.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/gmac/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samE5x.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/miim/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/library/tcpip/src
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/: arp.c dhcp.c dns.c hash_fnv.c icmp.c ipv4.c oahash.c tcp.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c udp.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/library/tcpip/src/common
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/evsys
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/sercom/usart
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/usart/: plib_sercom2_usart.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/tc
    ../src/config/sam_e54_xpro_iar/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/stdio
    ../src/config/sam_e54_xpro_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system
    ../src/config/sam_e54_xpro_iar/system/: sys_time_h2_adapter.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/cache
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/command
    ../src/config/sam_e54_xpro_iar/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/console
    ../src/config/sam_e54_xpro_iar/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/debug
    ../src/config/sam_e54_xpro_iar/system/debug/src/: sys_debug.c sys_debug_local.h
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/int
    ../src/config/sam_e54_xpro_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/time
    ../src/config/sam_e54_xpro_iar/system/time/src/: sys_time.c
