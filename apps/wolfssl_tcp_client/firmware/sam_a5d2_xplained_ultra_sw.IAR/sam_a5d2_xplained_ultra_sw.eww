<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sam_a5d2_xplained_ultra_sw.ewp</path>
    </project>
    <batchBuild />
</workspace>
