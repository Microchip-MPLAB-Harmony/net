# IAR project tcpip_udp_client_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: __SAM9X60__
  ICCARM.CCDiagSuppress: Pe188, Pe186, Pe1029
  ICCARM.CCIncludePath2: ..\src\config\sam_9x60_ek_freertos\library; ..\src\config\sam_9x60_ek_freertos\library\tcpip\src; ..\src\config\sam_9x60_ek_freertos\library\tcpip\src\common; ..\src; ..\src\config\sam_9x60_ek_freertos; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\src\third_party\rtos\FreeRTOS\Source\include; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_freertos\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
    ../src/config/sam_9x60_ek_freertos/driver/emac/: drv_emac.h
    ../src/config/sam_9x60_ek_freertos/driver/emac/src/dynamic/: drv_emac_dcpt_lists.h drv_emac_lib.h
    ../src/config/sam_9x60_ek_freertos/driver/emac/src/: drv_emac_local.h
    ../src/config/sam_9x60_ek_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos
    ../src/config/sam_9x60_ek_freertos/: configuration.h definitions.h device_cache.h FreeRTOSConfig.h system_config.h system_definitions.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/bsp
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver
    ../src/config/sam_9x60_ek_freertos/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/ethphy
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/ethphy/src
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic/: drv_extphy_ksz8081.h drv_extphy_regs.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/miim
    ../src/config/sam_9x60_ek_freertos/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/miim/src
    ../src/config/sam_9x60_ek_freertos/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/miim/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/library/tcpip
    ../src/config/sam_9x60_ek_freertos/library/tcpip/: arp.h berkeley_api.h ddns.h dhcp.h dhcps.h dhcpv6.h dns.h dnss.h ftp.h ftpc.h http.h http_net.h icmp.h icmpv6.h igmp.h iperf.h ipv4.h ipv6.h lldp.h nbns.h ndp.h smtp.h smtpc.h snmp.h snmpv3.h sntp.h tcp.h tcpip.h tcpip_announce.h tcpip_commands.h tcpip_common_ports.h tcpip_ethernet.h tcpip_heap.h tcpip_helpers.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_reboot.h telnet.h tftpc.h tftps.h udp.h zero_conf_link_local.h zero_conf_multicast_dns.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/library/tcpip/src
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/: arp_manager.h arp_private.h berkeley_manager.h ddns_manager.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcpv6_manager.h dhcpv6_private.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h hash_fnv.h http_manager.h http_net_manager.h http_net_private.h http_private.h icmp_manager.h icmpv6_manager.h igmp_manager.h igmp_private.h iperf_manager.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h link_list.h lldp_manager.h lldp_private.h lldp_tlv.h nbns_manager.h ndp_manager.h ndp_private.h oahash.h smtp_manager.h smtpc_manager.h smtpc_private.h snmp_manager.h snmp_private.h snmpv3_private.h sntp_manager.h tcp_manager.h tcp_private.h tcpip_announce_manager.h tcpip_commands_manager.h tcpip_heap_alloc.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_reboot_manager.h tcpip_types.h telnet_manager.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h udp_manager.h udp_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/library/tcpip/src/common
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/net_pres/pres
    ../src/config/sam_9x60_ek_freertos/net_pres/pres/: net_pres.h net_pres_socketapi.h net_pres_socketapiconversion.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/dbgu
    ../src/config/sam_9x60_ek_freertos/peripheral/dbgu/: plib_dbgu.h plib_dbgu_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: cp15.h plib_mmu.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system
    ../src/config/sam_9x60_ek_freertos/system/: sys_clk_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h sys_time_h2_adapter.h system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/cache
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/command
    ../src/config/sam_9x60_ek_freertos/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/console
    ../src/config/sam_9x60_ek_freertos/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/debug
    ../src/config/sam_9x60_ek_freertos/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/int
    ../src/config/sam_9x60_ek_freertos/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/time
    ../src/config/sam_9x60_ek_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek_freertos/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/Include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_freertos/: ddram.icf
  group Harmony3/Source Files
    ../src/: app.c app_commands.c main_sam_9x60.c
    ../src/config/sam_9x60_ek_freertos/driver/emac/src/dynamic/: drv_emac.c drv_emac_lib_SAM9X60.c drv_emac_statistics.c
    ../src/config/sam_9x60_ek_freertos/osal/: osal_freertos.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos
    ../src/config/sam_9x60_ek_freertos/: cstartup.s freertos_hooks.c initialization.c interrupts.c tasks.c vectortrap.s
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/bsp
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/driver/miim/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/library/tcpip/src
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/: arp.c dhcp.c dns.c hash_fnv.c icmp.c ipv4.c nbns.c oahash.c tcp.c tcpip_announce.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c udp.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/library/tcpip/src/common
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/dbgu
    ../src/config/sam_9x60_ek_freertos/peripheral/dbgu/: plib_dbgu.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_freertos/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/stdio
    ../src/config/sam_9x60_ek_freertos/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system
    ../src/config/sam_9x60_ek_freertos/system/: sys_time_h2_adapter.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/cache
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/command
    ../src/config/sam_9x60_ek_freertos/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/console
    ../src/config/sam_9x60_ek_freertos/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/debug
    ../src/config/sam_9x60_ek_freertos/system/debug/src/: sys_debug.c sys_debug_local.h
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/int
    ../src/config/sam_9x60_ek_freertos/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/time
    ../src/config/sam_9x60_ek_freertos/system/time/src/: sys_time.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: FreeRTOS_tick_config.c port.c portASM.s
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_3.c
