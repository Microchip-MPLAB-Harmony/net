# IAR project ipv4Connectivity.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: __PIC32C__
  ICCARM.CCDiagSuppress: Pe186, Pe188
  ICCARM.CCIncludePath2: ..\..\firmware\src\config\sam_a5d2_xult\library; ..\..\firmware\src\config\sam_a5d2_xult\library\tcpip\src; ..\..\firmware\src\config\sam_a5d2_xult\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: ipv4Connectivity.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult/: sam_a5d2_xult.ipcf
  group IAR Project Connection File/Header Files
    ../src/config/sam_a5d2_xult/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/config/sam_a5d2_xult/library/tcpip/: arp.h berkeley_api.h ddns.h dhcp.h dhcps.h dhcpv6.h dns.h dnss.h ftp.h http.h http_net.h icmp.h icmpv6.h igmp.h iperf.h ipv4.h ipv6.h lldp.h nbns.h ndp.h smtp.h smtpc.h snmp.h snmpv3.h sntp.h tcp.h tcpip.h tcpip_announce.h tcpip_commands.h tcpip_common_ports.h tcpip_ethernet.h tcpip_heap.h tcpip_helpers.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_reboot.h telnet.h tftpc.h tftps.h udp.h zero_conf_link_local.h zero_conf_multicast_dns.h
    ../src/config/sam_a5d2_xult/library/tcpip/src/: arp_manager.h arp_private.h berkeley_manager.h ddns_manager.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcpv6_manager.h dhcpv6_private.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h hash_fnv.h http_manager.h http_net_manager.h http_net_private.h http_private.h icmp_manager.h icmpv6_manager.h igmp_manager.h igmp_private.h iperf_manager.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h link_list.h lldp_manager.h lldp_private.h lldp_tlv.h nbns_manager.h ndp_manager.h ndp_private.h oahash.h smtp_manager.h smtpc_manager.h smtpc_private.h snmp_manager.h snmp_private.h snmpv3_private.h sntp_manager.h tcp_manager.h tcp_private.h tcpip_announce_manager.h tcpip_commands_manager.h tcpip_heap_alloc.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_reboot_manager.h tcpip_types.h telnet_manager.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h udp_manager.h udp_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult/: configuration.h definitions.h device_cache.h system_config.h system_definitions.h toolchain_specifics.h user.h
    ../src/config/sam_a5d2_xult/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_a5d2_xult/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xult/driver/ethphy/: drv_ethphy.h
    ../src/config/sam_a5d2_xult/driver/ethphy/src/: drv_ethphy_local.h
    ../src/config/sam_a5d2_xult/driver/ethphy/src/dynamic/: drv_extphy_ksz8081.h drv_extphy_regs.h
    ../src/config/sam_a5d2_xult/driver/gmac/: drv_gmac.h
    ../src/config/sam_a5d2_xult/driver/gmac/src/: drv_gmac_local.h
    ../src/config/sam_a5d2_xult/driver/memory/: drv_memory.h drv_memory_definitions.h
    ../src/config/sam_a5d2_xult/driver/memory/src/: drv_memory_local.h
    ../src/config/sam_a5d2_xult/driver/miim/: drv_miim.h
    ../src/config/sam_a5d2_xult/driver/miim/config/: drv_miim_config.h
    ../src/config/sam_a5d2_xult/driver/miim/src/: drv_miim_local.h
    ../src/config/sam_a5d2_xult/driver/miim/src/dynamic/: drv_miim_mapping.h
    ../src/config/sam_a5d2_xult/driver/mx25l/: drv_mx25l.h drv_mx25l_definitions.h
    ../src/config/sam_a5d2_xult/driver/mx25l/src/: drv_mx25l_local.h
    ../src/config/sam_a5d2_xult/driver/sdmmc/: drv_sdmmc.h drv_sdmmc_definitions.h
    ../src/config/sam_a5d2_xult/driver/sdspi/: drv_sdspi.h drv_sdspi_definitions.h
    ../src/config/sam_a5d2_xult/driver/sdspi/src/: drv_sdspi_local.h drv_sdspi_plib_interface.h
    ../src/config/sam_a5d2_xult/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_a5d2_xult/library/tcpip/src/common/: helpers.h sys_fs_wrapper.h
    ../src/config/sam_a5d2_xult/system/fs/mpfs/: mpfs.h
    ../src/config/sam_a5d2_xult/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_a5d2_xult/net_pres/pres/: net_pres.h net_pres_certstore.h net_pres_enc_glue.h net_pres_encryptionproviderapi.h net_pres_socketapi.h net_pres_socketapiconversion.h net_pres_transportapi.h
    ../src/config/sam_a5d2_xult/net_pres/pres/src/: net_pres_local.h
    ../src/config/sam_a5d2_xult/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.h
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xult/peripheral/qspi/: plib_qspi0.h plib_qspi_common.h
    ../src/config/sam_a5d2_xult/peripheral/sdmmc/: plib_sdmmc1.h plib_sdmmc_common.h
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi0.h plib_spi_common.h
    ../src/config/sam_a5d2_xult/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/config/sam_a5d2_xult/peripheral/uart/: plib_uart1.h plib_uart_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xult/system/: sys_clk_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h sys_time_h2_adapter.h system.h system_common.h system_media.h system_module.h
    ../src/config/sam_a5d2_xult/system/console/: sys_command.h sys_console.h sys_debug.h
    ../src/config/sam_a5d2_xult/system/console/src/: sys_console_local.h sys_console_uart.h sys_console_uart_definitions.h sys_debug_local.h
    ../src/config/sam_a5d2_xult/system/dma/: sys_dma.h sys_dma_mapping.h
    ../src/config/sam_a5d2_xult/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_a5d2_xult/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_a5d2_xult/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xult/system/ports/: sys_ports.h sys_ports_mapping.h
    ../src/config/sam_a5d2_xult/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult/system/time/src/: sys_time_local.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xult/library/tcpip/src/: arp.c dhcp.c dns.c hash_fnv.c helpers.c http_net.c icmp.c iperf.c ipv4.c oahash.c smtpc.c sntp.c tcp.c tcpip_announce.c tcpip_commands.c tcpip_heap_alloc.c tcpip_heap_internal.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c telnet.c tftpc.c udp.c
    ../src/config/sam_a5d2_xult/bsp/: bsp.c
    ../src/config/sam_a5d2_xult/: cstartup.s exceptions.c initialization.c interrupts.c tasks.c vectortrap.s
    ../src/config/sam_a5d2_xult/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_a5d2_xult/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
    ../src/config/sam_a5d2_xult/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samA5D2.c
    ../src/config/sam_a5d2_xult/driver/memory/src/: drv_memory.c drv_memory_file_system.c
    ../src/config/sam_a5d2_xult/driver/miim/src/dynamic/: drv_miim.c
    ../src/config/sam_a5d2_xult/driver/mx25l/src/: drv_mx25l.c
    ../src/config/sam_a5d2_xult/driver/sdmmc/src/: drv_sdmmc.c drv_sdmmc_file_system.c drv_sdmmc_local.h
    ../src/config/sam_a5d2_xult/driver/sdspi/src/: drv_sdspi.c drv_sdspi_file_system.c drv_sdspi_plib_interface.c
    ../src/config/sam_a5d2_xult/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xult/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_a5d2_xult/net_pres/pres/src/: net_pres.c
    ../src/config/sam_a5d2_xult/net_pres/pres/: net_pres_enc_glue.c
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.c
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult/peripheral/qspi/: plib_qspi0.c
    ../src/config/sam_a5d2_xult/peripheral/sdmmc/: plib_sdmmc1.c
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi0.c
    ../src/config/sam_a5d2_xult/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xult/peripheral/uart/: plib_uart1.c
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xult/system/console/src/: sys_command.c sys_console.c sys_console_uart.c sys_debug.c
    ../src/config/sam_a5d2_xult/system/dma/: sys_dma.c
    ../src/config/sam_a5d2_xult/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_a5d2_xult/library/tcpip/src/common/: sys_fs_wrapper.c
    ../src/config/sam_a5d2_xult/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xult/system/time/src/: sys_time.c
    ../src/config/sam_a5d2_xult/system/: sys_time_h2_adapter.c
