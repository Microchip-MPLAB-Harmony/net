# IAR project tcpip_tcp_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: __SAM9X60__
  ICCARM.CCDiagSuppress: Pe188, Pe186, Pe1029
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\src\config\sam_9x60_ek\library; ..\src\config\sam_9x60_ek\library\tcpip\src; ..\src\config\sam_9x60_ek\library\tcpip\src\common; ..\src; ..\src\config\sam_9x60_ek; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\..\firmware\src\config\sam_9x60_ek\library; ..\..\firmware\src\config\sam_9x60_ek\library\tcpip\src; ..\..\firmware\src\config\sam_9x60_ek\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\firmware\src\config\sam_9x60_ek\library; ..\..\firmware\src\config\sam_9x60_ek\library\tcpip\src; ..\..\firmware\src\config\sam_9x60_ek\library\tcpip\src\common; ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: tcpip_tcp_server.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: __SAM9X60__; NDEBUG
  ILINK.IlinkOutputFile: tcpip_udp_server.out
  group Harmony3/Header Files
    ../src/config/sam_9x60_ek/driver/emac/: drv_emac.h
    ../src/config/sam_9x60_ek/driver/emac/src/: drv_emac_local.h
    ../src/config/sam_9x60_ek/driver/emac/src/dynamic/: drv_emac_dcpt_lists.h drv_emac_lib.h
    ../src/config/sam_9x60_ek/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek
    ../src/config/sam_9x60_ek/: system_config.h system_definitions.h user.h configuration.h device_cache.h toolchain_specifics.h definitions.h
  group Harmony3/Header Files/config/sam_9x60_ek/bsp
    ../src/config/sam_9x60_ek/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/tc
    ../src/config/sam_9x60_ek/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/mmu
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/clk
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/pio
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/aic
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/dbgu
    ../src/config/sam_9x60_ek/peripheral/dbgu/: plib_dbgu_common.h plib_dbgu.h
  group Harmony3/Header Files/config/sam_9x60_ek/system
    ../src/config/sam_9x60_ek/system/: sys_clk_h2_adapter.h sys_time_h2_adapter.h sys_random_h2_adapter.h sys_reset_h2_adapter.h system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/time
    ../src/config/sam_9x60_ek/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/int
    ../src/config/sam_9x60_ek/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/cache
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/debug
    ../src/config/sam_9x60_ek/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/command
    ../src/config/sam_9x60_ek/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/console
    ../src/config/sam_9x60_ek/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_9x60_ek/library/tcpip
    ../src/config/sam_9x60_ek/library/tcpip/: tcpip_common_ports.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_heap.h tcpip_helpers.h ndp.h ipv4.h ipv6.h icmpv6.h dhcpv6.h arp.h udp.h tcp.h berkeley_api.h dhcp.h dhcps.h zero_conf_link_local.h zero_conf_multicast_dns.h dns.h dnss.h ftp.h ftpc.h icmp.h nbns.h ddns.h telnet.h smtp.h sntp.h http.h http_net.h snmp.h snmpv3.h tcpip_announce.h lldp.h smtpc.h igmp.h tftpc.h tftps.h tcpip_reboot.h iperf.h tcpip_commands.h tcpip.h tcpip_ethernet.h
  group Harmony3/Header Files/config/sam_9x60_ek/library/tcpip/src
    ../src/config/sam_9x60_ek/library/tcpip/src/: tcpip_heap_alloc.h ndp_manager.h ndp_private.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h icmp_manager.h icmpv6_manager.h arp_manager.h arp_private.h udp_manager.h udp_private.h tcp_manager.h tcp_private.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h nbns_manager.h ddns_manager.h telnet_manager.h smtp_manager.h sntp_manager.h http_manager.h http_private.h http_net_manager.h http_net_private.h snmp_manager.h snmp_private.h snmpv3_private.h tcpip_announce_manager.h smtpc_manager.h smtpc_private.h igmp_manager.h igmp_private.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h tcpip_reboot_manager.h iperf_manager.h tcpip_commands_manager.h hash_fnv.h link_list.h oahash.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_types.h berkeley_manager.h dhcpv6_manager.h dhcpv6_private.h lldp_manager.h lldp_private.h lldp_tlv.h
  group Harmony3/Header Files/config/sam_9x60_ek/library/tcpip/src/common
    ../src/config/sam_9x60_ek/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_9x60_ek/net_pres/pres
    ../src/config/sam_9x60_ek/net_pres/pres/: net_pres.h net_pres_socketapi.h net_pres_socketapiconversion.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver
    ../src/config/sam_9x60_ek/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/miim
    ../src/config/sam_9x60_ek/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/miim/src
    ../src/config/sam_9x60_ek/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/miim/src/dynamic
    ../src/config/sam_9x60_ek/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/ethphy
    ../src/config/sam_9x60_ek/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/ethphy/src
    ../src/config/sam_9x60_ek/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/ethphy/src/dynamic
    ../src/config/sam_9x60_ek/driver/ethphy/src/dynamic/: drv_extphy_regs.h drv_extphy_ksz8081.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Source Files
    ../src/config/sam_9x60_ek/driver/emac/src/dynamic/: drv_emac.c drv_emac_statistics.c drv_emac_lib_SAM9X60.c
    ../src/: app.c main_sam_9x60.c
  group Harmony3/Source Files/config/sam_9x60_ek
    ../src/config/sam_9x60_ek/: tasks.c initialization.c interrupts.c cstartup.s vectortrap.s
  group Harmony3/Source Files/config/sam_9x60_ek/bsp
    ../src/config/sam_9x60_ek/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek/library/tcpip/src
    ../src/config/sam_9x60_ek/library/tcpip/src/: icmp.c nbns.c tcp.c arp.c tcpip_commands.c ipv4.c tcpip_heap_alloc.c tcpip_heap_internal.c dhcp.c dns.c hash_fnv.c oahash.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c tcpip_announce.c udp.c
  group Harmony3/Source Files/config/sam_9x60_ek/library/tcpip/src/common
    ../src/config/sam_9x60_ek/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/tc
    ../src/config/sam_9x60_ek/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/mmu
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/clk
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/pio
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/aic
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/dbgu
    ../src/config/sam_9x60_ek/peripheral/dbgu/: plib_dbgu.c
  group Harmony3/Source Files/config/sam_9x60_ek/system
    ../src/config/sam_9x60_ek/system/: sys_time_h2_adapter.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/time
    ../src/config/sam_9x60_ek/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/console
    ../src/config/sam_9x60_ek/system/console/src/: sys_console_uart.h sys_console_uart_definitions.h sys_console_uart.c sys_console.c sys_console_local.h
  group Harmony3/Source Files/config/sam_9x60_ek/system/int
    ../src/config/sam_9x60_ek/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/cache
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/command
    ../src/config/sam_9x60_ek/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/debug
    ../src/config/sam_9x60_ek/system/debug/src/: sys_debug_local.h sys_debug.c
  group Harmony3/Source Files/config/sam_9x60_ek/stdio
    ../src/config/sam_9x60_ek/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek/driver/miim/src/dynamic
    ../src/config/sam_9x60_ek/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_9x60_ek/driver/ethphy/src/dynamic
    ../src/config/sam_9x60_ek/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek/: ddram.icf
